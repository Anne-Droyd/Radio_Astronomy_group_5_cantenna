options:
  parameters:
    generate_options: qt_gui
    id: group5_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: frequency
  id: variable
  parameters:
    value: '1420000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: vec_len
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: vec_len
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: data8_veclen2048
    type: float
    vlen: vec_len
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_len
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: vec_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(vec_len)
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"hackrf,bias=1"'
    bb_gain0: '32'
    freq0: frequency
    gain0: '14'
    gain_mode0: 'False'
    if_gain0: '32'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: vec_len
    type: complex
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_file_sink_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [osmosdr_source_0, '0', blocks_stream_to_vector_0, '0']
- [osmosdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
